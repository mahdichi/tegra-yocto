FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://csi-sensor.cfg"

